# IAR project sc1086.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_LD_VL
  ICCSTM8.CCIncludePath2: ..\user; ..\std_lib\STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\Libraries\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: sc1086.bin
  ILINK.IlinkOutputFile: sc1086.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group STM8L_StdPeriph_Lib
    ../std_lib/STM8L15x-16x-05x-AL31-L_StdPeriph_Lib/Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_syscfg.c stm8l15x_tim3.c stm8l15x_usart.c stm8l15x_wfe.c
  group user
    ../user/: adc_func.c common.c gp_sub.c initialization.c key_process.c main.c my_printf.c ntc.c oled_6448.c rtc.c stm8l15x_it.c th_test.c uart.c
