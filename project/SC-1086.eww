<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SC-1086.ewp</path>
    </project>
    <batchBuild />
</workspace>
